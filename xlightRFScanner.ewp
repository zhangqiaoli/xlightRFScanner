# IAR project xlightRFScanner.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S105K4 STM8S105K4
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8S105
  ICCSTM8.CCIncludePath2: STM8S_StdPeriph_Driver\inc; $PROJ_DIR$; Project\inc
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: xlightRFScanner.hex
  ILINK.IlinkOutputFile: xlightRFScanner.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  General.GenDeviceSelectMenu: UnspecifiedSTM8 STM8 - Unspecified
  ICCSTM8.CCDefines: STM8S105; NDEBUG
  ICCSTM8.CCIncludePath2: STM8S_StdPeriph_Driver\inc; $PROJ_DIR$
  group STM8S Library/inc
    STM8S_StdPeriph_Driver/inc/: stm8s_clk.h stm8s_exti.h stm8s_flash.h stm8s_gpio.h stm8s_spi.h stm8s_tim4.h stm8s_uart2.h stm8s_wwdg.h
  group STM8S Library/src
    STM8S_StdPeriph_Driver/src/: stm8s_clk.c stm8s_exti.c stm8s_flash.c stm8s_gpio.c stm8s_spi.c stm8s_tim4.c stm8s_uart2.c stm8s_wwdg.c
  group User/inc
    Project/inc/: _global.h cfg_zensensor.h MyMessage.h ProtocolParser.h rf24l01.h SerialConsole.h stm8s_conf.h stm8s_it.h timer_4.h Uart2Dev.h xliNodeConfig.h
  group User/src
    Project/src/: main.c ProtocolParser.c rf24l01.c SerialConsole.c timer_4.c Uart2Dev.c
